# Keil uVision project STM32L496AGIx.uvprojx, settings and files
target STM32L496AGIx (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32L496AGIx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.6.1
  cpu: IRAM(0x20000000-0x2004FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: STM32L496AGIx
  AfterMake: fromelf.exe --bin -o  ./STM32L496AGIx/@L.bin  ./STM32L496AGIx/@L.axf
  AfterMake: a20_combine STM32L496AGIx\@L.bin 0x40000 0.91 0 developerkit_fw_ldrom.bin 1 developerkit_fw.bin
  c flags: OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L496xx,AOS_SENSOR,AOS_VFS,AOS_FRAMEWORK_COMMON,AOS_UDATA,CONFIG_AOS_FATFS_SUPPORT_MMC
  c misc: --C99 -DSYSINFO_OS_VERSION=\"APP-1.0.0\" -DSYSINFO_PRODUCT_MODEL=\"ALI_AOS_STM32L496AGIx\" -DSYSINFO_DEVICE_NAME=\"STM32LL496AGIx\" -DSYSINFO_KERNEL_VERSION=\"AOS-R-1.1.2\" -DSYSINFO_APP_VERSION=\"APP-1.0.0\" -DSTDIO_UART=0 -DCONFIG_NO_TCPIP -DRHINO_CONFIG_TICK_TASK=0 -DCONFIG_AOS_KV_MULTIPTN_MODE -DCONFIG_AOS_KV_PTN=6 -DCONFIG_AOS_KV_SECOND_PTN=7 -DCONFIG_AOS_KV_PTN_SIZE=4096 -DCONFIG_AOS_KV_BUFFER_SIZE=8192 -D__BSD_VISIBLE -DRHINO_CONFIG_TICK_TASK=0
  c include: ..\utility\inc;..\sensor\include;..\main\include;..\main\hal\inc;..\main\APP\inc;..\kernel\inc;..\kernel\rhino\include;..\GUI\STemWin\inc;..\GUI\core\include;..\framework\include;..\Drivers\STM32L4xx_HAL_Driver\Inc;..\Drivers\CMSIS\Device\ST\STM32L4xx\Include;..\Config\inc;..\armv7m\armcc\m4;..\include\aos\internal;..\include\hal\soc;..\include\aos;..\include\hal;..\utility\libc\compilers\armlibc;..\utility\libc\compilers\armlibc\sys;..\utility\libc\compilers\armlibc\RVMDK;..\Drivers\STM32L4xx_HAL_Driver\Inc\Legacy;..\Drivers\CMSIS\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x50000
  link misc: --diag_suppress=L6329
  group aos
    ../aos/: soc_impl.c trace_impl.c
  group armv7m
    ../armv7m/armcc/m4/: port_c.c port_c.s
  group Config
    ../Config/: GUIConf.c LCDConf_FlexColor_Template.c
  group framework
    ../framework/uData/: abs_data_model.c calibrated_example_algo.c service_mgr.c uData_interface.c uData_main.c
    ../framework/common/: main.c version.c
  group GUI
    ../GUI/core/: GUI_init.c
    ../GUI/STemWin/OS/: GUI_X_rhino.c
    ../GUI/STemWin/Lib/: STemWin540_CM4_OS_Keil_ot.lib
  group GUIDEMO
    ../GUIDEMO/: GUIDEMO.c GUIDEMO_BarGraph.c GUIDEMO_ColorBar.c GUIDEMO_Conf.c GUIDEMO_Graph.c GUIDEMO_Intro.c GUIDEMO_Resource.c GUIDEMO_Start.c GUIDEMO_TransparentDialog.c GUIDEMO_Uncalssified.c
  group main
    ../main/: audio.c gc0329.c irda.c isd9160.c main.c soc_init.c st7789.c stm32l4xx_hal_msp.c stm32l4xx_it.c system_stm32l4xx.c
    ../main/APP/: atdemo.c camera_demo.c crc16.c id2_client_demo.c nuoxing_id2.lib
    ../main/hal/: hal_gpio_stm32l4.c hal_i2c_stm32l4.c hal_sd_stm32l4.c hal_smartcard_stm32l4.c hal_uart_stm32l4.c
    ./: startup_stm32l496xx_keil.s
  group sensor
    ../sensor/drv/: drv_acc_gyro_temp_st_lsm6dsl.c drv_als_ps_liteon_ltr553.c drv_baro_bosch_bmp280.c drv_mag_temp_memsic_mmc3680kj.c drv_temp_humi_sensirion_shtc1.c
    ../sensor/hal/: sensor_drv_api.c sensor_hal.c
  group utility
    ../utility/: base64.c CheckSumUtils.c crc.c digest_algorithm.c hmac.c log.c md5.c
  group kernel
    ../kernel/aos/: aos_rhino.c
    ../kernel/fatfs/: diskio.c fatfs.c ff.c ffunicode.c
    ../kernel/init/: aos_init.c
    ../kernel/rhino/: k_buf_queue.c k_dyn_mem_proc.c k_err.c k_event.c k_fifo.c k_idle.c k_mm.c k_mm_blk.c k_mm_debug.c k_mutex.c k_obj.c k_obj_set.c k_pend.c k_queue.c k_ringbuf.c k_sched.c k_sem.c k_stats.c k_sys.c k_task.c k_task_sem.c k_tick.c k_time.c k_timer.c k_trace.c k_workqueue.c
    ../kernel/vfs/: device.c vfs.c vfs_inode.c vfs_register.c
    ../kernel/yloop/: local_event.c yloop.c
  group Drivers
    ../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_adc.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal_can.c stm32l4xx_hal_comp.c stm32l4xx_hal_cortex.c stm32l4xx_hal_crc.c stm32l4xx_hal_crc_ex.c stm32l4xx_hal_cryp.c stm32l4xx_hal_cryp_ex.c stm32l4xx_hal_dac.c stm32l4xx_hal_dac_ex.c stm32l4xx_hal_dcmi.c stm32l4xx_hal_dfsdm.c stm32l4xx_hal_dfsdm_ex.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_dma2d.c stm32l4xx_hal_dsi.c stm32l4xx_hal_firewall.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gfxmmu.c stm32l4xx_hal_gpio.c stm32l4xx_hal_hash.c stm32l4xx_hal_hash_ex.c stm32l4xx_hal_hcd.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_irda.c stm32l4xx_hal_iwdg.c stm32l4xx_hal_lcd.c stm32l4xx_hal_lptim.c stm32l4xx_hal_ltdc.c stm32l4xx_hal_ltdc_ex.c stm32l4xx_hal_nand.c stm32l4xx_hal_nor.c stm32l4xx_hal_opamp.c stm32l4xx_hal_opamp_ex.c stm32l4xx_hal_ospi.c stm32l4xx_hal_pcd.c stm32l4xx_hal_pcd_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_qspi.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_rng.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_sai.c stm32l4xx_hal_sai_ex.c stm32l4xx_hal_sd.c stm32l4xx_hal_sd_ex.c stm32l4xx_hal_smartcard.c stm32l4xx_hal_smartcard_ex.c stm32l4xx_hal_smbus.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_sram.c stm32l4xx_hal_swpmi.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_tsc.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_usart.c stm32l4xx_hal_usart_ex.c stm32l4xx_hal_wwdg.c stm32l4xx_ll_adc.c stm32l4xx_ll_comp.c stm32l4xx_ll_crc.c stm32l4xx_ll_crs.c stm32l4xx_ll_dac.c stm32l4xx_ll_dma.c stm32l4xx_ll_dma2d.c stm32l4xx_ll_exti.c stm32l4xx_ll_fmc.c stm32l4xx_ll_gpio.c stm32l4xx_ll_i2c.c stm32l4xx_ll_lptim.c stm32l4xx_ll_lpuart.c stm32l4xx_ll_opamp.c stm32l4xx_ll_pwr.c stm32l4xx_ll_rcc.c stm32l4xx_ll_rng.c stm32l4xx_ll_rtc.c stm32l4xx_ll_sdmmc.c stm32l4xx_ll_spi.c stm32l4xx_ll_swpmi.c stm32l4xx_ll_tim.c stm32l4xx_ll_usart.c stm32l4xx_ll_usb.c stm32l4xx_ll_utils.c
software components: CMSIS:CORE 4.3.0
